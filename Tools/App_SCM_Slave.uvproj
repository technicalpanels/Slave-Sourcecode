# Keil uVision project App_SCM_Slave.uvproj, settings and files
target App_SCM_Slave_Module (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: App_SCM_Slave +hex
  AfterMake: .\Objects\Con_Hex2Bin.exe .\Objects\App_SCM_Slave.hex .\Objects\00_BIN_Release\App_Slave_M.bin 32768
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA1
  c misc: --c99
  c include: ..\Driver;..\Driver\driverlib;..\Bsw;..\Bsw\USB_ADK;..\Driver\simplelink\include;..\Appl
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\Objects\App_SCM_Slave.sct
  group MDK
    ../Make/: startup_rvmdk.S
  group Appl
    ../Appl/main/: Appl.c
    ../Appl/monitorcontrol/: iohandler.c
    ../Appl/slavecontrol/: slave_ctrl.c Side_Mod.c CAB_Mod.c Vault_Mod.c Rear_Mod.c
    ../Appl/canbuscontrol/: commandctrl.c
  group Inc
    ../Bsw/: Platform.h
    ../Bsw/port/: gpio_app.h
    ../Appl/slavecontrol/: slave_ctrl.h
    ../Bsw/can/: hcan.h
  group RTE
    ../Bsw/rte/: rte.h
  group Bsw
    ../Bsw/port/: gpio_app.c
    ../Bsw/odm/: odm.c
    ../Bsw/: interrupt.c
    ../Bsw/can/: hcan.c
    ../Bsw/wiegand/: wiegand.c
  group Driver
    ../Driver/driverlib/: cpu.c fpu.c gpio.c i2c.c interrupt.c sysexc.c sysctl.c udma.c usb.c watchdog.c ssi.c can.c
  group TM4C1294_Platform
    ../Bsw/TM4C1294_Platform/: HAL_Dev_Initial.c
